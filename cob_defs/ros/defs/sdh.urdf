Commit message: colors for visual elements

File: cob_defs/ros/defs/sdh.urdf (robot description, URDF)
Before this commit: robot sdh, 10 links, 9 joints
Joints:
- joint joint_palm_finger21: axis 0 0 1 -> 0 0 -1
